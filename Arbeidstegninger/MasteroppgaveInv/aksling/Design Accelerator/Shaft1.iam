# Autodesk Inventor assembly: Shaft
## iProperties
Created: 2010-04
Part Number: Shaft
Document SubType Name: Assembly
Designer: a31883
ClientObjectVersion: 1
Author: a31883
