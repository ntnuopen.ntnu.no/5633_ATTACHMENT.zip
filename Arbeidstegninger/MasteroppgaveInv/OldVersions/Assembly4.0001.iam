# Autodesk Inventor assembly: Assembly4
## iProperties
Created: 2010-01
Part Number: Assembly4
Document SubType Name: Assembly
Designer: a31883
Author: a31883
