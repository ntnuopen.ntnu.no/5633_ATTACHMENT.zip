# Autodesk Inventor assembly: Assembly5
## iProperties
Created: 2010-01
Part Number: Assembly5
Document SubType Name: Weldment
Designer: a31883
Weld Material: Welded Aluminum-6061
Author: a31883
