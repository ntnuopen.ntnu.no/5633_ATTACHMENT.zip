# Autodesk Inventor assembly: aksling
## iProperties
Created: 2010-04
Part Number: aksling
Document SubType Name: Weldment
Designer: a31883
Weld Material: Welded Aluminum-6061
Author: a31883
