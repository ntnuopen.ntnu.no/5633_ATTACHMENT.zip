# Autodesk Inventor assembly: impelleognav
## iProperties
Created: 2010-02
Part Number: impelleognav
Document SubType Name: Assembly
Designer: a31883
Author: a31883
